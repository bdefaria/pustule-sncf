COMPATIBLE_MACHINE_panda = "panda"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://defconfig"
